# Keil uVision project ncpu.uvprojx, settings and files
target ncpu (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: Mozart_ncpu
  AfterMake: fromelf.exe --bin "!L" --output ".\Objects\fw_ncpu.bin"
  AfterMake: post_build.bat fw_ncpu.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM4, TARGET_NCPU, LOG_ENABLE, KL520
  c include: ..\..\..\..\platform\kl520\common;..\..\..\..\platform\kl520\ncpu\rtos\rtx\include;..\..\..\..\platform\kl520\ncpu\drv\include;..\..\..\..\platform\kl520\ncpu\model_ppp\include;..\..\..\..\include
  asm misc: --cpreproc
  asm include: ..\..\..\..\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0xfff0000 size 0x10000
  scatter file: ..\..\..\..\platform\kl520\ncpu\mozart_ncpu.sct
  group main
    ../../main_ncpu/: main.c user_pre_process.c user_post_process.c model_ftr_table.c
  group libs
    ../../../../lib/: kdp2_ncpu_sdk.lib kdp2_ncpu_model_ppp.lib
  group rtx
    ../../../../platform/kl520/ncpu/rtos/rtx/: irq_cm4f.s os_systick.c RTX_Config.c rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_lib.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
  group startup
    ../../../../platform/kl520/ncpu/startup/: startup.c startup_asm.s
