# Keil uVision project scpu.uvprojx, settings and files
target dev (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: scpu_fw
  BeforeMake: pre_build.bat
  AfterMake: fromelf.exe --bin "!L" --output ".\Objects\fw_scpu.bin"
  AfterMake: post_build.bat fw_scpu.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM4, KL520, TARGET_SCPU, LOG_ENABLE
  c misc: --gnu
  c include: ..\..\..\..\include;..\..\..\..\platform\kl520\common;..\..\..\..\platform\kl520\scpu\drv\include;..\..\..\..\platform\kl520\scpu\rtos\rtx\include;..\..\..\..\platform\board\board_sn52096;..\..\..\..\platform\dev\include;..\..\..\..\mdw\include;..\..\..\..\mdw\inference;..\..\..\..\app;..\..\main_scpu\include;..\;..\..\..\lib\system_520\main_scpu\include
  asm misc: --cpreproc
  asm include: ..\..\sn52096;..\..\..\..\include;..\..\..\..\platform\kl520\common;..\..\..\..\platform\board\board_sn52096
  library: MicroLIB
  memory RVCT4: ROM 0x10102000 size 0x16000
  memory RVCT9: RAM 0x10200000 size 0x16000
  scatter file: ..\..\..\..\platform\kl520\scpu\scatter_load.sct
  group main
    ../../main_scpu/: main.c application_init.c system_init.c device_init.c driver_init.c middleware_init.c
    ../: project.h
    ../../main_scpu/include/: task_handler.h
  group inf_app
    ../../../../app/: demo_customize_inf_single_model.c demo_customize_inf_multiple_models.c kdp2_inf_app_yolo.c
  group inf_client
    ../../../../mdw/usb_companion/: kdp2_cmd_handler_520.c kdp2_usb_companion.c usbd_hal_520.c kdp2_usb_log.c
  group middleware
    ../../../../mdw/memory/: kmdw_memory.c
    ../../../../mdw/flash/: kmdw_memxfer.c
    ../../../../mdw/console/: kmdw_console.c
    ../../../../mdw/power/: kmdw_power_manager.c
    ../../../../mdw/dfu/: kmdw_dfu.c
    ../../../../mdw/utils/: kmdw_utils_crc.c
    ../../../../mdw/system/: kmdw_system.c
    ../../../../mdw/ipc/: kmdw_ipc.c
    ../../../../mdw/model/: kmdw_model.c
    ../../../../mdw/inference/: dual_fifo2.c kdp2_inf_generic_raw.c kmdw_inference_520.c kmdw_fifoq_manager.c
  group device
    ../../../../platform/dev/flash/: kdev_flash_winbond.c
  group driver
    ../../../../platform/kl520/scpu/drv/: kdrv_pinmux.c kdrv_gpio.c kdrv_spif.c kdrv_uart.c kdrv_ipc.c kdrv_ncpu.c kdrv_usbd2.c kdrv_usbd2v.c kdrv_clock.c kdrv_mpu.c kdrv_ddr.c kdrv_power.c kdrv_system.c kdrv_wdt.c kdrv_gdma.c rtc.c kdrv_pwm.c
  group rtx
    ../../../../platform/kl520/scpu/rtos/rtx/: irq_cm4f.s os_systick.c RTX_Config.c rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_lib.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c task_handler.c
  group startup
    ../../../../platform/kl520/scpu/startup/: startup.c startup_asm.s
  group libs
    ../../../../lib/: system_520.lib
